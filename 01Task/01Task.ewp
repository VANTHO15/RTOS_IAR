# IAR project 01Task.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_mem_idioms; --no_wrap_diagnostics; --do_explicit_zero_opt_in_named_sections
  ICCARM.CCIncludePath2: F:\RTOS\FreeRTOS202212_Core_M4\include; F:\RTOS\FreeRTOS202212_Core_M4\portable\IAR\ARM_CM4F; F:\RTOS\FreeRTOS202212_Core_M4; F:\RTOS\RTOS_Project\01Task\Gpio\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: F:\RTOS\FreeRTOS202212_Core_M4
  AARM.AExtraOptionsV2: --cpu_mode thumb
  OBJCOPY.OOCOutputFile: 01Task.hex
  ILINK.IlinkOutputFile: 01Task.out
  ILINK.IlinkIcfFile: F:\RTOS\RTOS_Project\01Task\linker\ThoNV_stm32f407.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --no_wrap_diagnostics
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group FreeRTOS202212_Core_M4
    ../../FreeRTOS202212_Core_M4/: croutine.c event_groups.c list.c queue.c sbom.spdx stream_buffer.c tasks.c timers.c
  group FreeRTOS202212_Core_M4/Gpio
    Gpio/source/: stm32f407xx_gpio_driver.c
  group FreeRTOS202212_Core_M4/portable/IAR/ARM_CM4F
    ../../FreeRTOS202212_Core_M4/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRTOS202212_Core_M4/portable/MemMang
    ../../FreeRTOS202212_Core_M4/portable/MemMang/: heap_4.c
  group Starup_up
    starupfile/: stm32_startup.s
