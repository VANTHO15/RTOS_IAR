<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\01Task.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\Tessy\Config_IAR_For_Tessy\ProjectOne.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\Tessy\Ptm\tessy\config\iar_dummy\ts_slave.ewp</path>
    </project>
    <batchBuild />
</workspace>
