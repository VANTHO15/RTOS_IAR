# IAR project 01_Task_YTB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: --no_mem_idioms; --no_wrap_diagnostics; --do_explicit_zero_opt_in_named_sections
  ICCARM.CCIncludePath2: F:\RTOS\RTOS_Project\FreeRTOS\Source\include; F:\RTOS\RTOS_Project\FreeRTOS\Source\portable\IAR\ARM_CM4F; F:\RTOS\RTOS_Project\FreeRTOS\Source; F:\RTOS\RTOS_Project\01_Task_YTB\Gpio\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: F:\RTOS\RTOS_Project\FreeRTOS\Source
  AARM.AExtraOptionsV2: --cpu_mode thumb
  OBJCOPY.OOCOutputFile: 01_Task_YTB.hex
  ILINK.IlinkOutputFile: 01_Task_YTB.out
  ILINK.IlinkIcfFile: F:\RTOS\RTOS_Project\01_Task_YTB\linker\ThoNV_stm32f407.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --no_wrap_diagnostics
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/portable/IAR_M4
    ../FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group FreeRTOS/portable/MemMang
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Gpio
    Gpio/source/: stm32f407xx_gpio_driver.c
  group Starup_File
    starupfile/: stm32_startup.s
